RD #10
OUT 1
OUT 11
RD #103
OUT 1

RDI 1001
OUT 22

M1:
IN 0
JZ M1

WR R2
RD R1
OUT 13
ADI #1
WR R1
RD R2
OUT 10

JNS CMPRUS

CMPRUS:
RD R2
SBI #224
JS M4
JMP M2

M4:
RD R2
SBI #128
JS M2

RD R0
OUT 10
ADI #1
WR R0
RD R2
OUT 10

RD R1
OUT 13
ADI #1
WR R1
RD R2
OUT 10

RDI 1001     
SBI #15       
JS TIMER_CHECK 
CALL CLEAR     

TIMER_CHECK:
JMP M2

M2:
RD R1
SUB #48
JZ M3
JMP M1

M3:
RD #101
OUT 1
RD #0
WR R1
JMP M1

CLEAR:
RD #0     
WR R1
WR R2
WR R0
OUT 1    
IN 1        
RET          