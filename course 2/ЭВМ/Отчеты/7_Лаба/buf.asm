RD #10
OUT 1
OUT 11
RD #103
OUT 1

M1:
IN 0
JZ M1
WR R2
RD R1
OUT 13
ADI #1
WR R1
RD R2
OUT 10
JNS CMPRUS

CMPRUS:
RD R2
SBI #224
JS M4
JMP M2

M4:
RD R2
SBI #128
JS M2

RD R0
OUT 10
ADI #1
WR R0
RD R2
OUT 10
JMP M2

M2:
RD R1
SUB #48
JZ M3
JMP M1

M3:
RD #101
OUT 1
RD #0
WR R1
JMP M1