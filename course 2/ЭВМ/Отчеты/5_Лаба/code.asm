RD #50
WR R1
RD #10
WR R2
CALL M
WR R6

RD #60
WR R1
RD #10
WR R2
CALL M
WR R7

RD #70
WR R1
RD #10
WR R2
CALL M

ADD R7
ADD R6
DIV #3
OUT
HLT

M:
RD #0
WR R3
RD #0
WR R4
RD #0
WR R5

L2:
RD @R1+
WR R5
DIV #2
MUL #2
SUB R5
JNZ M2
RD R5
ADD R3
WR R3
JMP M3

M2:
RD R5
ADD R4
WR R4

M3:
JRNZ R2,L2

RD R3
DIV R4
WR R3
RET